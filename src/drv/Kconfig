## src/drv/Kconfig
```kconfig
config SOFTATHOME_DOWNLOADERAPI
	tristate "downloader API kernel driver"
	default m
	help
		This is downloader API kernel driver code
```
